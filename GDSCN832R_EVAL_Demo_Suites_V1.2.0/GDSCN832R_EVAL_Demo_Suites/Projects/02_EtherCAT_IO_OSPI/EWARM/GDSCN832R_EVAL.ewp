# IAR project GDSCN832R_EVAL.ewp, settings and files
configuration GD32H7xx (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX; GD32H7XXI; USE_SPI
  ICCARM.CCIncludePath2: ..\..\..\..\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include; ..; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include; ..\..\..\Utilites; ..\EtherCAT\gdesc; ..\EtherCAT\Src; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_esc_library\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../EtherCAT/gdesc/: exti.c gdesc.c timer.c
    ../: gd32h7xx_it.c main.c systick.c
  group CMSIS
    ../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group ESC_Hardware
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_esc_library/Source/: esc_intc.c esc_phy.c esc_pmu.c esc_spi.c esc_syscfg.c esc_timer.c
  group EtherCAT_Stack
    ../EtherCAT/Src/: coeappl.c ecatappl.c ecatcoe.c ecatslv.c GDESC_IO.c mailbox.c objdef.c sdoserv.c
  group GD32H7xx_Peripherals
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Startup
    ../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
